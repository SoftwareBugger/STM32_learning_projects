# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\libraries\CM3;.\libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: stm32f10x_it.c main.c
  group Startup
    ./libraries/CM3/: startup_stm32f10x_hd.s
  group CMSIS
    ./libraries/CM3/: system_stm32f10x.c
  group StdPeriph_Driver
    ./libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group APP
    ./APP/led/: led.c led.h
  group Public
    ./Public/: system.c system.h
